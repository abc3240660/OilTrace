# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MALLOC +hex
  AfterMake: fromelf.exe   --bin -o  ..\OBJ\MALLOC.bin ..\OBJ\MALLOC.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\FLASH;..\HARDWARE\TIMER;..\MALLOC;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\HARDWARE\DMA;..\HARDWARE\STMFLASH;..\HARDWARE\IAP;..\HARDWARE\SPI;..\HARDWARE\MCP3204;..\HARDWARE\W25QXX;..\HARDWARE\AD3204
  memory RVCT4: ROM 0x8019000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c gagent_md5.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/MCP3204/: mcp3204.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/AD3204/: ad.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group MALLOC
    ../MALLOC/: malloc.c
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_spi.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s os_cpu.h
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group LIB
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/IAP/: iap.c
